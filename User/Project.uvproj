# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SourceProgram;..\SDK
  group Source Group 1
    ../SourceProgram/: main.c Delay.C Uart3.c Key.C MQ-5.c
  group SDK
    ../SDK/: mcu_api.c protocol.c system.c
